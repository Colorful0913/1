# Keil uVision project 13-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 13-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./A51/: CHA13-1.A51
